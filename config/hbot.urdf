Commit message: use cartographer, it works

File: config/hbot.urdf (robot description, URDF)
Before this commit: robot hbot, 4 links, 3 joints
Joints:
- joint lidar_joint: origin xyz=0.08 0 0.14 rpy=0 0 3.14 -> xyz=0.08 0 0.14 rpy=0 0 0
